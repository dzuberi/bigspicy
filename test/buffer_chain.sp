**TEST
.INCLUDE /opt/bigspicy/test/asap7sc7p5t_28_L.sp

** SPICE netlist generated by bigspicy.py at ThXu Jun  5 02:06:56 2025 UTC
.SUBCKT buffer_chain VDD VSS in out
** [instance Xu0 of INVx1_ASAP7_75t_L, params={} connections=['A: [connection u0/A =>[signal: u0:A w=1]]', 'Y: [connection u0/Y =>[signal: u0:Y w=1]]']]
Xu0 VSS VDD u0_A u0_Y INVx1_ASAP7_75t_L
** [instance Xu1 of INVx1_ASAP7_75t_L, params={} connections=['A: [connection u1/A =>[signal: u1:A w=1]]', 'Y: [connection u1/Y =>[signal: u1:Y w=1]]']]
Xu1 VSS VDD u1_A u1_Y INVx1_ASAP7_75t_L
** [instance Xu2 of INVx1_ASAP7_75t_L, params={} connections=['A: [connection u2/A =>[signal: u2:A w=1]]', 'Y: [connection u2/Y =>[signal: u2:Y w=1]]']]
Xu2 VSS VDD u2_A u2_Y INVx1_ASAP7_75t_L
** [instance Xu3 of INVx1_ASAP7_75t_L, params={} connections=['A: [connection u3/A =>[signal: u3:A w=1]]', 'Y: [connection u3/Y =>[signal: u3:Y w=1]]']]
Xu3 VSS VDD u3_A u3_Y INVx1_ASAP7_75t_L
** [instance Xu4 of INVx1_ASAP7_75t_L, params={} connections=['A: [connection u4/A =>[signal: u4:A w=1]]', 'Y: [connection u4/Y =>[signal: u4:Y w=1]]']]
Xu4 VSS VDD u4_A u4_Y INVx1_ASAP7_75t_L
** [instance Xu5 of INVx1_ASAP7_75t_L, params={} connections=['A: [connection u5/A =>[signal: u5:A w=1]]', 'Y: [connection u5/Y =>[signal: u5:Y w=1]]']]
Xu5 VSS VDD u5_A u5_Y INVx1_ASAP7_75t_L
** [instance Xu6 of INVx1_ASAP7_75t_L, params={} connections=['A: [connection u6/A =>[signal: u6:A w=1]]', 'Y: [connection u6/Y =>[signal: u6:Y w=1]]']]
Xu6 VSS VDD u6_A u6_Y INVx1_ASAP7_75t_L
** [instance Xu7 of INVx1_ASAP7_75t_L, params={} connections=['A: [connection u7/A =>[signal: u7:A w=1]]', 'Y: [connection u7/Y =>[signal: u7:Y w=1]]']]
Xu7 VSS VDD u7_A u7_Y INVx1_ASAP7_75t_L
** [instance Xu8 of INVx1_ASAP7_75t_L, params={} connections=['A: [connection u8/A =>[signal: u8:A w=1]]', 'Y: [connection u8/Y =>[signal: u8:Y w=1]]']]
Xu8 VSS VDD u8_A u8_Y INVx1_ASAP7_75t_L
** [instance Xu9 of INVx1_ASAP7_75t_L, params={} connections=['A: [connection u9/A =>[signal: u9:A w=1]]', 'Y: [connection u9/Y =>[signal: u9:Y w=1]]']]
Xu9 VSS VDD u9_A u9_Y INVx1_ASAP7_75t_L
** [instance Xu10 of INVx1_ASAP7_75t_L, params={} connections=['A: [connection u10/A =>[signal: u10:A w=1]]', 'Y: [connection u10/Y =>[signal: u10:Y w=1]]']]
Xu10 VSS VDD u10_A u10_Y INVx1_ASAP7_75t_L
** [instance Xu11 of INVx1_ASAP7_75t_L, params={} connections=['A: [connection u11/A =>[signal: u11:A w=1]]', 'Y: [connection u11/Y =>[signal: u11:Y w=1]]']]
Xu11 VSS VDD u11_A u11_Y INVx1_ASAP7_75t_L
** [instance Xu12 of INVx1_ASAP7_75t_L, params={} connections=['A: [connection u12/A =>[signal: u12:A w=1]]', 'Y: [connection u12/Y =>[signal: u12:Y w=1]]']]
Xu12 VSS VDD u12_A u12_Y INVx1_ASAP7_75t_L
** [instance C0 of CAPACITOR, params={'capacitance': 1.59740454e-05 prefix:SIUnitPrefix.PICO} connections=['A: [connection C0/A =>[signal: *1 w=1]]', 'B: [connection C0/B =>[signal: VSS w=1]]']]
C0 _1 VSS  C=1.5974045399999998E-17
** [instance C1 of CAPACITOR, params={'capacitance': 1.59740454e-05 prefix:SIUnitPrefix.PICO} connections=['A: [connection C1/A =>[signal: u0:A w=1]]', 'B: [connection C1/B =>[signal: VSS w=1]]']]
C1 u0_A VSS  C=1.5974045399999998E-17
** [instance C2 of CAPACITOR, params={'capacitance': 8.34463e-06 prefix:SIUnitPrefix.PICO} connections=['A: [connection C2/A =>[signal: *2 w=1]]', 'B: [connection C2/B =>[signal: VSS w=1]]']]
C2 _2 VSS  C=8.34463E-18
** [instance C3 of CAPACITOR, params={'capacitance': 5.18561e-06 prefix:SIUnitPrefix.PICO} connections=['A: [connection C3/A =>[signal: out:2 w=1]]', 'B: [connection C3/B =>[signal: VSS w=1]]']]
C3 out_2 VSS  C=5.185609999999999E-18
** [instance C4 of CAPACITOR, params={'capacitance': 5.36444e-06 prefix:SIUnitPrefix.PICO} connections=['A: [connection C4/A =>[signal: out:3 w=1]]', 'B: [connection C4/B =>[signal: VSS w=1]]']]
C4 out_3 VSS  C=5.36444E-18
** [instance C5 of CAPACITOR, params={'capacitance': 8.52346436e-06 prefix:SIUnitPrefix.PICO} connections=['A: [connection C5/A =>[signal: out:4 w=1]]', 'B: [connection C5/B =>[signal: VSS w=1]]']]
C5 out_4 VSS  C=8.523464359999999E-18
** [instance C6 of CAPACITOR, params={'capacitance': 3.57627869e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C6/A =>[signal: u0:Y w=1]]', 'B: [connection C6/B =>[signal: VSS w=1]]']]
C6 u0_Y VSS  C=3.57627869E-19
** [instance C7 of CAPACITOR, params={'capacitance': 3.57627869e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C7/A =>[signal: u1:A w=1]]', 'B: [connection C7/B =>[signal: VSS w=1]]']]
C7 u1_A VSS  C=3.57627869E-19
** [instance C8 of CAPACITOR, params={'capacitance': 3.57627869e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C8/A =>[signal: u1:Y w=1]]', 'B: [connection C8/B =>[signal: VSS w=1]]']]
C8 u1_Y VSS  C=3.57627869E-19
** [instance C9 of CAPACITOR, params={'capacitance': 3.57627869e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C9/A =>[signal: u2:A w=1]]', 'B: [connection C9/B =>[signal: VSS w=1]]']]
C9 u2_A VSS  C=3.57627869E-19
** [instance C10 of CAPACITOR, params={'capacitance': 3.57627869e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C10/A =>[signal: u2:Y w=1]]', 'B: [connection C10/B =>[signal: VSS w=1]]']]
C10 u2_Y VSS  C=3.57627869E-19
** [instance C11 of CAPACITOR, params={'capacitance': 3.57627869e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C11/A =>[signal: u3:A w=1]]', 'B: [connection C11/B =>[signal: VSS w=1]]']]
C11 u3_A VSS  C=3.57627869E-19
** [instance C12 of CAPACITOR, params={'capacitance': 3.57627869e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C12/A =>[signal: u3:Y w=1]]', 'B: [connection C12/B =>[signal: VSS w=1]]']]
C12 u3_Y VSS  C=3.57627869E-19
** [instance C13 of CAPACITOR, params={'capacitance': 3.57627869e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C13/A =>[signal: u4:A w=1]]', 'B: [connection C13/B =>[signal: VSS w=1]]']]
C13 u4_A VSS  C=3.57627869E-19
** [instance C14 of CAPACITOR, params={'capacitance': 7.74860382e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C14/A =>[signal: u4:Y w=1]]', 'B: [connection C14/B =>[signal: VSS w=1]]']]
C14 u4_Y VSS  C=7.748603819999999E-19
** [instance C15 of CAPACITOR, params={'capacitance': 7.74860382e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C15/A =>[signal: u5:A w=1]]', 'B: [connection C15/B =>[signal: VSS w=1]]']]
C15 u5_A VSS  C=7.748603819999999E-19
** [instance C16 of CAPACITOR, params={'capacitance': 4.17232513e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C16/A =>[signal: u5:Y w=1]]', 'B: [connection C16/B =>[signal: VSS w=1]]']]
C16 u5_Y VSS  C=4.1723251299999998E-19
** [instance C17 of CAPACITOR, params={'capacitance': 4.17232513e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C17/A =>[signal: temp5:2 w=1]]', 'B: [connection C17/B =>[signal: VSS w=1]]']]
C17 temp5_2 VSS  C=4.1723251299999998E-19
** [instance C18 of CAPACITOR, params={'capacitance': 1.01327896e-06 prefix:SIUnitPrefix.PICO} connections=['A: [connection C18/A =>[signal: u6:Y w=1]]', 'B: [connection C18/B =>[signal: VSS w=1]]']]
C18 u6_Y VSS  C=1.01327896E-18
** [instance C19 of CAPACITOR, params={'capacitance': 1.01327896e-06 prefix:SIUnitPrefix.PICO} connections=['A: [connection C19/A =>[signal: u7:A w=1]]', 'B: [connection C19/B =>[signal: VSS w=1]]']]
C19 u7_A VSS  C=1.01327896E-18
** [instance C20 of CAPACITOR, params={'capacitance': 7.15255737e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C20/A =>[signal: u7:Y w=1]]', 'B: [connection C20/B =>[signal: VSS w=1]]']]
C20 u7_Y VSS  C=7.15255737E-19
** [instance C21 of CAPACITOR, params={'capacitance': 7.15255737e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C21/A =>[signal: u8:A w=1]]', 'B: [connection C21/B =>[signal: VSS w=1]]']]
C21 u8_A VSS  C=7.15255737E-19
** [instance C22 of CAPACITOR, params={'capacitance': 4.17232513e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C22/A =>[signal: u8:Y w=1]]', 'B: [connection C22/B =>[signal: VSS w=1]]']]
C22 u8_Y VSS  C=4.1723251299999998E-19
** [instance C23 of CAPACITOR, params={'capacitance': 4.17232513e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C23/A =>[signal: temp8:2 w=1]]', 'B: [connection C23/B =>[signal: VSS w=1]]']]
C23 temp8_2 VSS  C=4.1723251299999998E-19
** [instance C24 of CAPACITOR, params={'capacitance': 4.76843e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C24/A =>[signal: u9:Y w=1]]', 'B: [connection C24/B =>[signal: VSS w=1]]']]
C24 u9_Y VSS  C=4.768429999999999E-19
** [instance C25 of CAPACITOR, params={'capacitance': 5.96041e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C25/A =>[signal: u10:A w=1]]', 'B: [connection C25/B =>[signal: VSS w=1]]']]
C25 u10_A VSS  C=5.96041E-19
** [instance C26 of CAPACITOR, params={'capacitance': 1.07288361e-06 prefix:SIUnitPrefix.PICO} connections=['A: [connection C26/A =>[signal: temp9:2 w=1]]', 'B: [connection C26/B =>[signal: VSS w=1]]']]
C26 temp9_2 VSS  C=1.07288361E-18
** [instance C27 of CAPACITOR, params={'capacitance': 8.34465027e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C27/A =>[signal: u10:Y w=1]]', 'B: [connection C27/B =>[signal: VSS w=1]]']]
C27 u10_Y VSS  C=8.34465027E-19
** [instance C28 of CAPACITOR, params={'capacitance': 8.34465027e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C28/A =>[signal: temp10:2 w=1]]', 'B: [connection C28/B =>[signal: VSS w=1]]']]
C28 temp10_2 VSS  C=8.34465027E-19
** [instance C29 of CAPACITOR, params={'capacitance': 3.57627869e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C29/A =>[signal: u11:Y w=1]]', 'B: [connection C29/B =>[signal: VSS w=1]]']]
C29 u11_Y VSS  C=3.57627869E-19
** [instance C30 of CAPACITOR, params={'capacitance': 3.57627869e-07 prefix:SIUnitPrefix.PICO} connections=['A: [connection C30/A =>[signal: temp11:2 w=1]]', 'B: [connection C30/B =>[signal: VSS w=1]]']]
C30 temp11_2 VSS  C=3.57627869E-19
** [instance R0 of RESISTOR, params={'resistance': 340.443 prefix:None} connections=['A: [connection R0/A =>[signal: *1 w=1]]', 'B: [connection R0/B =>[signal: u0:A w=1]]']]
R0 _1 u0_A  R=340.443
** [instance R1 of RESISTOR, params={'resistance': 161.952 prefix:None} connections=['A: [connection R1/A =>[signal: *2 w=1]]', 'B: [connection R1/B =>[signal: out:4 w=1]]']]
R1 _2 out_4  R=161.952
** [instance R2 of RESISTOR, params={'resistance': 201.230652 prefix:None} connections=['A: [connection R2/A =>[signal: out:2 w=1]]', 'B: [connection R2/B =>[signal: out:3 w=1]]']]
R2 out_2 out_3  R=201.230652
** [instance R3 of RESISTOR, params={'resistance': 24.8345 prefix:None} connections=['A: [connection R3/A =>[signal: out:3 w=1]]', 'B: [connection R3/B =>[signal: out:4 w=1]]']]
R3 out_3 out_4  R=24.8345
** [instance R4 of RESISTOR, params={'resistance': 4.99883 prefix:None} connections=['A: [connection R4/A =>[signal: u12:Y w=1]]', 'B: [connection R4/B =>[signal: out:2 w=1]]']]
R4 u12_Y out_2  R=4.99883
** [instance R5 of RESISTOR, params={'resistance': 18.4602 prefix:None} connections=['A: [connection R5/A =>[signal: u0:Y w=1]]', 'B: [connection R5/B =>[signal: u1:A w=1]]']]
R5 u0_Y u1_A  R=18.4602
** [instance R6 of RESISTOR, params={'resistance': 18.4602 prefix:None} connections=['A: [connection R6/A =>[signal: u1:Y w=1]]', 'B: [connection R6/B =>[signal: u2:A w=1]]']]
R6 u1_Y u2_A  R=18.4602
** [instance R7 of RESISTOR, params={'resistance': 18.4602 prefix:None} connections=['A: [connection R7/A =>[signal: u2:Y w=1]]', 'B: [connection R7/B =>[signal: u3:A w=1]]']]
R7 u2_Y u3_A  R=18.4602
** [instance R8 of RESISTOR, params={'resistance': 18.4602 prefix:None} connections=['A: [connection R8/A =>[signal: u3:Y w=1]]', 'B: [connection R8/B =>[signal: u4:A w=1]]']]
R8 u3_Y u4_A  R=18.4602
** [instance R9 of RESISTOR, params={'resistance': 37.2516 prefix:None} connections=['A: [connection R9/A =>[signal: u4:Y w=1]]', 'B: [connection R9/B =>[signal: u5:A w=1]]']]
R9 u4_Y u5_A  R=37.2516
** [instance R10 of RESISTOR, params={'resistance': 4.99991 prefix:None} connections=['A: [connection R10/A =>[signal: u6:A w=1]]', 'B: [connection R10/B =>[signal: temp5:2 w=1]]']]
R10 u6_A temp5_2  R=4.99991
** [instance R11 of RESISTOR, params={'resistance': 13.4601593 prefix:None} connections=['A: [connection R11/A =>[signal: u5:Y w=1]]', 'B: [connection R11/B =>[signal: temp5:2 w=1]]']]
R11 u5_Y temp5_2  R=13.4601593
** [instance R12 of RESISTOR, params={'resistance': 46.316 prefix:None} connections=['A: [connection R12/A =>[signal: u6:Y w=1]]', 'B: [connection R12/B =>[signal: u7:A w=1]]']]
R12 u6_Y u7_A  R=46.316
** [instance R13 of RESISTOR, params={'resistance': 37.2516 prefix:None} connections=['A: [connection R13/A =>[signal: u7:Y w=1]]', 'B: [connection R13/B =>[signal: u8:A w=1]]']]
R13 u7_Y u8_A  R=37.2516
** [instance R14 of RESISTOR, params={'resistance': 4.9999 prefix:None} connections=['A: [connection R14/A =>[signal: temp8:2 w=1]]', 'B: [connection R14/B =>[signal: u9:A w=1]]']]
R14 temp8_2 u9_A  R=4.9999
** [instance R15 of RESISTOR, params={'resistance': 17.0859108 prefix:None} connections=['A: [connection R15/A =>[signal: temp8:2 w=1]]', 'B: [connection R15/B =>[signal: u8:Y w=1]]']]
R15 temp8_2 u8_Y  R=17.0859108
** [instance R16 of RESISTOR, params={'resistance': 32.2515945 prefix:None} connections=['A: [connection R16/A =>[signal: temp9:2 w=1]]', 'B: [connection R16/B =>[signal: u10:A w=1]]']]
R16 temp9_2 u10_A  R=32.2515945
** [instance R17 of RESISTOR, params={'resistance': 15.273 prefix:None} connections=['A: [connection R17/A =>[signal: temp9:2 w=1]]', 'B: [connection R17/B =>[signal: u9:Y w=1]]']]
R17 temp9_2 u9_Y  R=15.273
** [instance R18 of RESISTOR, params={'resistance': 4.9999 prefix:None} connections=['A: [connection R18/A =>[signal: temp10:2 w=1]]', 'B: [connection R18/B =>[signal: u11:A w=1]]']]
R18 temp10_2 u11_A  R=4.9999
** [instance R19 of RESISTOR, params={'resistance': 17.0859108 prefix:None} connections=['A: [connection R19/A =>[signal: temp10:2 w=1]]', 'B: [connection R19/B =>[signal: u10:Y w=1]]']]
R19 temp10_2 u10_Y  R=17.0859108
** [instance R20 of RESISTOR, params={'resistance': 4.99991 prefix:None} connections=['A: [connection R20/A =>[signal: temp11:2 w=1]]', 'B: [connection R20/B =>[signal: u12:A w=1]]']]
R20 temp11_2 u12_A  R=4.99991
** [instance R21 of RESISTOR, params={'resistance': 13.4601593 prefix:None} connections=['A: [connection R21/A =>[signal: temp11:2 w=1]]', 'B: [connection R21/B =>[signal: u11:Y w=1]]']]
R21 temp11_2 u11_Y  R=13.4601593
R22 out out_4 R=0
.ENDS

* Simple stimulus for buffer_chain debug

Xbuf VDD VSS in out buffer_chain
VDD VDD 0 0.8
VSS VSS 0 0
VIN in 0 0

.DC VIN 0 0.8 0.01
.PRINT DC V(out)
.PRINT DC V(in)
.END
