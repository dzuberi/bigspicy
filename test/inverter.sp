**TEST
.INCLUDE /opt/bigspicy/test/asap7sc7p5t_28_L.sp

** SPICE netlist generated by bigspicy.py at ThXu Jun  5 02:06:56 2025 UTC
.SUBCKT inverter VDD VSS in out
** [instance Xu0 of INVx1_ASAP7_75t_L, params={} connections=['A: [connection u0/A =>[signal: u0:A w=1]]', 'Y: [connection u0/Y =>[signal: u0:Y w=1]]']]
Xu0 VSS VDD in out INVx1_ASAP7_75t_L
.ENDS

* Simple stimulus for buffer_chain debug

Xbuf VDD VSS in out inverter
VDD VDD 0 2.0
VSS VSS 0 0
VIN in 0 0

.OPTIONS OUTPUT OPALL NOOPTERMINALS
.DC VIN 0 2.0 0.01
.PRINT DC V(in)
.PRINT DC V(out)
.END
